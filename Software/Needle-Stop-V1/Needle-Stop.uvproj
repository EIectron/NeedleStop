# Keil uVision project Needle-Stop.uvproj, settings and files
target MS51EC0AE (MCS-51)
  device: MS51EC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: Needle-Stop
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\Needle-Stop-V1;.\Library\Device\Include;.\Library\Startup\Keil;.\Library\StdDriver\inc;.\Library\StdDriver\src
  group Application
    ./: main.c
  group Library
    ./Library/StdDriver/src/: common.c delay.c sys.c
  group Startup
    ./Library/Startup/Keil/: STARTUP.A51
